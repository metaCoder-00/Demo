# Keil uVision project 不用[].uvproj, settings and files
target Target 1 (MCS-51)
  device: T80C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: 不用[] +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 不用.c
